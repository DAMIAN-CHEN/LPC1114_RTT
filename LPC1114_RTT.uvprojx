# Keil uVision project LPC1114_RTT.uvprojx, settings and files
target LCP1114_RTT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LPC1114_RTT +hex
  AfterMake: fromelf --bin -o "$L@L.map" "#L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\LPC11XX;.\Doc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group LPC11XX
    ./LPC11XX/: core_cm0.h core_cmFunc.h core_cmInstr.h LPC11xx.h power_profiles.h startup_LPC11xx.s system_LPC11xx.c system_LPC11xx.h
  group MAIN
    ./MAIN/: main.c
  group Doc
    ./Doc/: Retarget.c timer.c uart.c
software components: RTOS:kernel 3.1.5
